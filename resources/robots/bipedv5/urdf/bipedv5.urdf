Commit message: 5 dof leg

File: resources/robots/bipedv5/urdf/bipedv5.urdf (robot description, URDF)
Before this commit: robot bipedv5, 13 links, 12 joints
Joints:
- joint lap: type prismatic -> fixed
- joint rap: type prismatic -> fixed
